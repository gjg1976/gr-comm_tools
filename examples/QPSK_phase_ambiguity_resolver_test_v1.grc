options:
  parameters:
    author: Gustavo Gonzalez
    description: This flow graph will test QPSK Phase Ambiguity Solver block
    generate_options: qt_gui
    id: QPSK_phase_ambiguity_resolver_test_v1
    output_language: python
    title: QPSK Phase Ambiguity Resolver Test v1
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])[-64:]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 64000*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '20'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''1ACFFC1D'''
  states: {}
- name: variable_cc_decoder_ccsds_c2noinv_def
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_encoder_ccsds_c2noinv_def
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79, 109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: variable_constellation_rect_qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[1+1j, 1-1j,-1+1j, -1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,3,1,2
    label: Rotation
    label0: 0॰
    label1: 90॰
    label2: 180॰
    label3: 270॰
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_chooser_1
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,2
    label: Normal/Reverse
    label0: Normal
    label1: Reverse
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: 1j
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: complex
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '-1j'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0_0_0_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: ./qpsk_IQ_out.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./random_AOS_frames.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0_0_0_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_0
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_0
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: comm_tools_qpsk_phase_ambiguity_solver_0
  id: comm_tools_qpsk_phase_ambiguity_solver
  parameters:
    sync_word: D49C24FF2686
    tag_lock_name: LOCK
    tolerance: '0'
  states: {}
- name: comm_tools_stream_to_iq_streams_0
  id: comm_tools_stream_to_iq_streams
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_rect_qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_rect_qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: access_code
    tagname: syncword
    threshold: '0'
    type: byte
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.0628'
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_ccsds_c2noinv_def
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: fec_generic_encoder_0_0
  id: fec_generic_encoder
  parameters:
    encoder: variable_cc_encoder_ccsds_c2noinv_def
    itype: byte
    otype: byte
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_utils_tags_to_pdu_X_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '1'
    eob_offset: '0'
    max_pdu_size: 1024*8
    prepend: '[]'
    pub_det: 'False'
    rate: samp_rate
    start_tag: syncword
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: variable_qtgui_msg_push_button_0_1_0_0_1_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Lock
    msgName: lock
    type: int
    value: '1'
  states: {}
- name: variable_qtgui_msg_push_button_0_1_0_0_1_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Unlock
    msgName: lock
    type: int
    value: '0'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_const_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_const_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_char_to_float_0_0, '0', fec_extended_decoder_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0, '0', blocks_float_to_complex_0_0_0_0_0, '1']
- [blocks_complex_to_float_0_0_0_0_0, '1', blocks_float_to_complex_0_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0_0, '0', blocks_float_to_complex_0_0_0_0_0_0, '1']
- [blocks_complex_to_float_0_0_0_0_0_0, '1', blocks_float_to_complex_0_0_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0_0_0, '0', blocks_float_to_complex_0_0_0_0_0_0_0, '1']
- [blocks_complex_to_float_0_0_0_0_0_0_0, '1', blocks_float_to_complex_0_0_0_0_0_0_0, '0']
- [blocks_complex_to_float_0_0_0_0_0_0_0_0, '0', blocks_float_to_complex_0_0_0_0_0_0_0_0, '1']
- [blocks_complex_to_float_0_0_0_0_0_0_0_0, '1', blocks_float_to_complex_0_0_0_0_0_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0_0_0_0_0, '0', blocks_selector_0_0, '0']
- [blocks_float_to_complex_0_0_0_0_0_0, '0', blocks_selector_0_0, '1']
- [blocks_float_to_complex_0_0_0_0_0_0_0, '0', blocks_selector_0_0, '2']
- [blocks_float_to_complex_0_0_0_0_0_0_0_0, '0', blocks_selector_0_0, '3']
- [blocks_multiply_xx_0, '0', blocks_complex_to_float_0_0_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_selector_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_float_0_0_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_selector_0, '2']
- [blocks_multiply_xx_0_0_0, '0', blocks_complex_to_float_0_0_0_0_0_0_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_selector_0, '3']
- [blocks_pack_k_bits_bb_0_0_0_0_0_0, '0', digital_constellation_modulator_0, '0']
- [blocks_pack_k_bits_bb_0_1_0, '0', blocks_file_sink_0_1, '0']
- [blocks_selector_0, '0', blocks_selector_0_0_0, '0']
- [blocks_selector_0_0, '0', blocks_selector_0_0_0, '1']
- [blocks_selector_0_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', fec_generic_encoder_0_0, '0']
- [comm_tools_qpsk_phase_ambiguity_solver_0, '0', digital_map_bb_0_0, '0']
- [comm_tools_qpsk_phase_ambiguity_solver_0, msg, blocks_message_debug_0, print]
- [comm_tools_stream_to_iq_streams_0, '0', comm_tools_qpsk_phase_ambiguity_solver_0, '0']
- [comm_tools_stream_to_iq_streams_0, '1', comm_tools_qpsk_phase_ambiguity_solver_0, '1']
- [digital_constellation_decoder_cb_0_1, '0', comm_tools_stream_to_iq_streams_0, '0']
- [digital_constellation_modulator_0, '0', blocks_complex_to_float_0_0_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_selector_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', pdu_utils_tags_to_pdu_X_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0_1, '0']
- [fec_extended_decoder_0_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [fec_generic_encoder_0_0, '0', blocks_pack_k_bits_bb_0_0_0_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_pack_k_bits_bb_0_1_0, '0']
- [pdu_utils_tags_to_pdu_X_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [variable_qtgui_msg_push_button_0_1_0_0_1_0, pressed, comm_tools_qpsk_phase_ambiguity_solver_0, ctrl]
- [variable_qtgui_msg_push_button_0_1_0_0_1_0_0, pressed, comm_tools_qpsk_phase_ambiguity_solver_0, ctrl]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
