options:
  parameters:
    author: Gustavo Gonzalez
    generate_options: qt_gui
    id: pdu_ambiguity_solver_test_v1
    output_language: python
    title: 'PDU Ambiguity Solver Test '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trg")
    period: '3000'
  states: {}
- name: comm_tools_pdu_phase_ambiguity_solver_0
  id: comm_tools_pdu_phase_ambiguity_solver
  parameters:
    modulation: '0'
    sync_word: 1ACFFC1D
    tag_lock_name: LOCK
    tolerance: '0'
  states: {}
- name: comm_tools_pdu_phase_ambiguity_solver_0_0
  id: comm_tools_pdu_phase_ambiguity_solver
  parameters:
    modulation: '1'
    sync_word: 1ACFFC1D
    tag_lock_name: LOCK
    tolerance: '0'
  states: {}
- name: satellite_tools_pdu_vector_source_0_0
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (1,1,0,0,0,1,1,0,1,0,1,1,0,0,1,1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,0,1,0,0,0,0,0)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_0
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (3, 0, 1, 2, 2, 3, 0, 3, 3, 3, 3, 3, 0, 0, 1, 3, 1, 0, 0, 1)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_0_0
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (3, 2, 0, 3, 3, 1, 2, 1, 1, 1, 1, 1, 2, 2, 0, 1,  0, 0, 1)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_0_0_0
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (3, 1, 0, 3, 3, 2, 1, 2, 2, 2, 2, 2, 1, 1, 0, 2, 0,  0, 0, 1)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_0_1
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (3, 3, 2, 1, 1, 0, 3, 0, 0, 0, 0, 0, 3, 3, 2, 0, 2, 0, 0, 1)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_0_1_0
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (3, 3, 1, 2, 2, 0, 3, 0, 0, 0, 0, 0, 3, 3, 1, 0, 1, 0, 0, 1)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_0_2
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (3, 1, 3, 0, 0, 2, 1, 2, 2, 2, 2, 2, 1, 1, 3, 2, 3, 0, 0, 1)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_0_2_0
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (3, 2, 3, 0, 0, 1, 2, 1, 1, 1, 1, 1, 2, 2, 3, 1, 3, 0, 0, 1)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_0_3
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (3, 0, 2, 1, 1, 3, 0, 3, 3, 3, 3, 3, 0, 0, 2, 3, 2, 0, 0, 1)
  states: {}
- name: satellite_tools_pdu_vector_source_0_0_1
  id: satellite_tools_pdu_vector_source
  parameters:
    vector: (1,1,1,1,1,0,0,1,0,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,1,1,1,1,1,0,0,0,1,0,1,1,1,1,1)
  states: {}

connections:
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_0, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_0_0, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_0_0_0, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_0_1, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_0_1_0, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_0_2, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_0_2_0, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_0_3, trg]
- [blocks_message_strobe_0, strobe, satellite_tools_pdu_vector_source_0_0_1, trg]
- [comm_tools_pdu_phase_ambiguity_solver_0, msg, blocks_message_debug_0_0, print]
- [comm_tools_pdu_phase_ambiguity_solver_0, pdu_out, blocks_message_debug_0_0, print]
- [comm_tools_pdu_phase_ambiguity_solver_0_0, msg, blocks_message_debug_0_0_0, print]
- [comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_out, blocks_message_debug_0_0_0, print]
- [satellite_tools_pdu_vector_source_0_0, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_0, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_0_0, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_0_0_0, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_0_1, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_0_1_0, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_0_2, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_0_2_0, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_0_3, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0_0, pdu_in]
- [satellite_tools_pdu_vector_source_0_0_1, pdu_out, comm_tools_pdu_phase_ambiguity_solver_0, pdu_in]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
