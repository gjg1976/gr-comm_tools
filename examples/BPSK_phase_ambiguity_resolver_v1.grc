options:
  parameters:
    author: Gustavo Gonzalez
    category: '[Satellite Tools]/Phase Disambiguity'
    description: Resolves Phase Ambiguity in a BPSK input bits
    generate_options: hb
    id: bpsk_phase_ambiguity_solver_bb
    output_language: python
    title: BPSK Phase Ambiguity Solver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: syncword_cc
  id: variable
  parameters:
    value: np.asarray(list(chain.from_iterable([list(j) for j in ([bin(int(i,16))[2:].zfill(4) for i in list(syncword_cc_hex)])]))).astype('int') * 2 -1
  states: {}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_1_0_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_or_xx_0_0_0_0_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size) - 0.5 - error_tolerance
    init: '0'
    low: (syncword_cc.size) - 0.5 - error_tolerance
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2) - 0.5 -  error_tolerance
    init: '0'
    low: (syncword_cc.size/2) - 0.5 - error_tolerance
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[int((-1)*syncword_cc.size),int(syncword_cc.size)]'
  states: {}
- name: error_tolerance
  id: parameter
  parameters:
    label: Error Tolerance
    type: intx
    value: '0'
  states: {}
- name: fir_filter_xxx_1_0_1_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword_cc[::-1]/syncword_cc.size
    type: fff
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0_0
  id: import
  parameters:
    imports: from itertools import chain
  states: {}
- name: lock_msg
  id: parameter
  parameters:
    hide: part
    label: Lock Msg
    type: str
    value: LOCK
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: msg
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: satellite_tools_latch_selector_0_0_0_1
  id: satellite_tools_latch_selector
  parameters:
    reset_key: RESET
    set_key: SET
    toggle_key: TOGGLE
    type: byte
    vlen: '1'
  states: {}
- name: satellite_tools_threshold_tag_0
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'False'
    high: '1'
    high_key: pmt.intern('RESET')
    initial_state: '0'
    low: '0'
    low_key: pmt.intern('LOW')
  states: {}
- name: satellite_tools_threshold_tag_0_0
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'False'
    high: '1'
    high_key: pmt.intern('SET')
    initial_state: '0'
    low: '0'
    low_key: pmt.intern('LOW')
  states: {}
- name: satellite_tools_threshold_tag_1
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'True'
    high: '1'
    high_key: lock_msg
    initial_state: '0'
    low: '0'
    low_key: unlock_msg
  states: {}
- name: syncword_cc_hex
  id: parameter
  parameters:
    label: Syncword
    type: str
    value: '''1ACFFC1D'''
  states: {}
- name: unlock_msg
  id: parameter
  parameters:
    hide: part
    label: Unlock Msg
    type: str
    value: UNLOCK
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: In_Phase
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Off_Phase
  states: {}
- name: virtual_sink_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: Input_Stream
  states: {}
- name: virtual_source_0_0_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: Off_Phase
  states: {}
- name: virtual_source_0_0_2_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: Input_Stream
  states: {}
- name: virtual_source_0_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: In_Phase
  states: {}

connections:
- [blocks_char_to_float_0_0_1, '0', fir_filter_xxx_1_0_1_0_1, '0']
- [blocks_float_to_char_0, '0', blocks_or_xx_0_0_0_0_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_0, '0']
- [blocks_float_to_char_0_1, '0', blocks_or_xx_0_0_0_0_0, '1']
- [blocks_float_to_char_0_1, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1_0_2_0_0, '0', blocks_threshold_ff_0_1, '0']
- [blocks_or_xx_0_0_0_0_0, '0', satellite_tools_threshold_tag_1, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_char_0_1, '0']
- [digital_map_bb_0_0, '0', satellite_tools_latch_selector_0_0_0_1, '1']
- [digital_map_bb_0_1, '0', blocks_char_to_float_0_0_1, '0']
- [fir_filter_xxx_1_0_1_0_1, '0', blocks_multiply_const_vxx_0_1_0_2_0_0, '0']
- [fir_filter_xxx_1_0_1_0_1, '0', blocks_threshold_ff_0, '0']
- [pad_source_0, '0', digital_map_bb_0_1, '0']
- [pad_source_0, '0', virtual_sink_0_0_2_0, '0']
- [satellite_tools_latch_selector_0_0_0_1, '0', pad_sink_0, '0']
- [satellite_tools_threshold_tag_0, cmd, satellite_tools_latch_selector_0_0_0_1, ctrl]
- [satellite_tools_threshold_tag_0_0, cmd, satellite_tools_latch_selector_0_0_0_1, ctrl]
- [satellite_tools_threshold_tag_1, cmd, pad_sink_0_0, in]
- [virtual_source_0_0_1_2_0_0, '0', satellite_tools_threshold_tag_0_0, '0']
- [virtual_source_0_0_2_0_0_0_1, '0', digital_map_bb_0_0, '0']
- [virtual_source_0_0_2_0_0_0_1, '0', satellite_tools_latch_selector_0_0_0_1, '0']
- [virtual_source_0_1_2_0_0, '0', satellite_tools_threshold_tag_0, '0']

metadata:
  file_format: 1
