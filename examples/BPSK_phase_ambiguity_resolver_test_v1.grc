options:
  parameters:
    author: Gustavo Gonzalez
    description: This flow graph will test BPS Phase Ambiguity resolver block
    generate_options: qt_gui
    id: bpsk_phase_ambiguity_resolver_test_v1
    output_language: python
    title: BPSK Phase Ambiguity Resolver Test v1
  states: {}

blocks:
- name: access_code
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword+1)//2])[-64:]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 64000*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '20'
  states: {}
- name: syncword
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''1ACFFC1D'''
  states: {}
- name: variable_constellation_rect_qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[1, -1]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '2'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: variable_qtgui_chooser_1
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,2
    label: Phase Rotation
    label0: Phase 0॰
    label1: Phase 180॰
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: complex
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /home/modem/041404/bpsk_output
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/modem/041404/Viterbi/random_AOS_frames.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: variable_qtgui_chooser_1
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: comm_tools_bpsk_phase_ambiguity_solver_0
  id: comm_tools_bpsk_phase_ambiguity_solver
  parameters:
    sync_word: 1ACFFC1D
    tag_lock_name: LOCK
    tolerance: '0'
  states: {}
- name: digital_constellation_decoder_cb_0_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_rect_qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_rect_qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: access_code
    tagname: syncword
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.0'
    loop_bw: '0.0628'
    max_dev: '1.5'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_utils_pack_unpack_0
  id: pdu_utils_pack_unpack
  parameters:
    bit_order: pdu_utils.BIT_ORDER_MSB_FIRST
    mode: pdu_utils.MODE_PACK_BYTE
  states: {}
- name: pdu_utils_tags_to_pdu_X_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '1'
    eob_offset: '0'
    max_pdu_size: 1024*8
    prepend: '[]'
    pub_det: 'False'
    rate: samp_rate
    start_tag: syncword
    start_time: '0.0'
    tail_size: '0'
    type: b
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: asm_lock
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: asm_lock
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_selector_0_0_0, '1']
- [blocks_pack_k_bits_bb_0_1_0, '0', blocks_file_sink_0_1, '0']
- [blocks_selector_0_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle_0, '0', digital_constellation_modulator_0, '0']
- [comm_tools_bpsk_phase_ambiguity_solver_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [comm_tools_bpsk_phase_ambiguity_solver_0, msg, virtual_sink_0, '0']
- [digital_constellation_decoder_cb_0_1, '0', comm_tools_bpsk_phase_ambiguity_solver_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_xx_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_selector_0_0_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', pdu_utils_tags_to_pdu_X_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0_1, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_pack_k_bits_bb_0_1_0, '0']
- [pdu_utils_pack_unpack_0, pdu_out, blocks_message_debug_0, print]
- [pdu_utils_tags_to_pdu_X_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_utils_tags_to_pdu_X_0, pdu_out, pdu_utils_pack_unpack_0, pdu_in]
- [virtual_source_0, '0', blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
