options:
  parameters:
    author: Gustavo Gonzalez
    category: '[Satellite Tools]/Phase Disambiguity'
    description: Resolves Phase Ambiguity in a QPSK input bits
    generate_options: hb
    id: qpsk_phase_ambiguity_solver_bb
    output_language: python
    title: QPSK Phase Ambiguity Solver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: syncword_cc
  id: variable
  parameters:
    value: np.asarray(list(chain.from_iterable([list(j) for j in ([bin(int(i,16))[2:].zfill(4) for i in list(syncword_cc_hex)])]))).astype('int') * 2 -1
  states: {}
- name: syncword_cc_I
  id: variable
  parameters:
    value: syncword_cc[::2]
  states: {}
- name: syncword_cc_Q
  id: variable
  parameters:
    value: syncword_cc[1::2]
  states: {}
- name: blocks_and_xx_0_1_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_1
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_1_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_1_0_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_1_1
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_2
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_2_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_and_xx_0_1_0_3
  id: blocks_and_xx
  parameters:
    type: byte
  states: {}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_1_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_1_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_2
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_0_2_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_1_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0_2_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1_0_2_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_or_xx_0_0
  id: blocks_or_xx
  parameters:
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_or_xx_0_0_0
  id: blocks_or_xx
  parameters:
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_or_xx_0_0_0_0
  id: blocks_or_xx
  parameters:
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_or_xx_0_0_0_0_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {}
- name: blocks_or_xx_0_1
  id: blocks_or_xx
  parameters:
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_or_xx_0_1_0
  id: blocks_or_xx
  parameters:
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    type: byte
  states: {}
- name: blocks_streams_to_stream_0
  id: blocks_streams_to_stream
  parameters:
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2) - 0.5 - error_tolerance
    init: '0'
    low: (syncword_cc.size/2) - 0.5 - error_tolerance
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2) - 0.5 - error_tolerance
    init: '0'
    low: (syncword_cc.size/2) - 0.5 - error_tolerance
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2) - 0.5 - error_tolerance
    init: '0'
    low: (syncword_cc.size/2) - 0.5 - error_tolerance
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2) - 0.5 -  error_tolerance
    init: '0'
    low: (syncword_cc.size/2) - 0.5 - error_tolerance
  states: {}
- name: blocks_threshold_ff_0_1_0
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2) - 0.5 - error_tolerance
    init: '0'
    low: (syncword_cc.size/2) - 0.5 - error_tolerance
  states: {}
- name: blocks_threshold_ff_0_1_0_0
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2)- 0.5 - error_tolerance
    init: '0'
    low: (syncword_cc.size/2)- 0.5 - error_tolerance
  states: {}
- name: blocks_threshold_ff_0_1_1
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2) - 0.5 - error_tolerance
    init: '0'
    low: (syncword_cc.size/2) - 0.5 - error_tolerance
  states: {}
- name: blocks_threshold_ff_0_2
  id: blocks_threshold_ff
  parameters:
    high: (syncword_cc.size/2) - 0.5 - error_tolerance
    init: '0'
    low: (syncword_cc.size/2) - 0.5 - error_tolerance
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[int((-1)*syncword_cc.size/2),int(syncword_cc.size/2)]'
  states: {}
- name: digital_map_bb_0_1_0
  id: digital_map_bb
  parameters:
    map: '[int((-1)*syncword_cc.size/2),int(syncword_cc.size/2)]'
  states: {}
- name: digital_map_bb_0_2
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: error_tolerance
  id: parameter
  parameters:
    label: Error Tolerance
    type: intx
    value: '0'
  states: {}
- name: fir_filter_xxx_1_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword_cc_I[::-1]/syncword_cc_I.size
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword_cc_I[::-1]/syncword_cc_I.size
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_1_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword_cc_Q[::-1]/syncword_cc_Q.size
    type: fff
  states: {}
- name: fir_filter_xxx_1_0_1_0_1_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword_cc_Q[::-1]/syncword_cc_Q.size
    type: fff
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_1_0_0
  id: import
  parameters:
    imports: from itertools import chain
  states: {}
- name: lock_msg
  id: parameter
  parameters:
    hide: part
    label: Lock Msg
    type: str
    value: LOCK
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: msg
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: satellite_tools_latch_selector_0
  id: satellite_tools_latch_selector
  parameters:
    reset_key: RESET
    set_key: SET
    toggle_key: TOGGLE
    type: byte
    vlen: '1'
  states: {}
- name: satellite_tools_latch_selector_0_0
  id: satellite_tools_latch_selector
  parameters:
    reset_key: RESET
    set_key: SET
    toggle_key: TOGGLE
    type: byte
    vlen: '1'
  states: {}
- name: satellite_tools_latch_selector_0_0_0
  id: satellite_tools_latch_selector
  parameters:
    reset_key: RESET
    set_key: SET
    toggle_key: TOGGLE
    type: byte
    vlen: '1'
  states: {}
- name: satellite_tools_latch_selector_0_0_0_0
  id: satellite_tools_latch_selector
  parameters:
    reset_key: RESET
    set_key: SET
    toggle_key: TOGGLE
    type: byte
    vlen: '1'
  states: {}
- name: satellite_tools_threshold_tag_0
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'True'
    high: '1'
    high_key: pmt.intern('RESET')
    low: '0'
    low_key: pmt.intern('LOW')
  states: {}
- name: satellite_tools_threshold_tag_0_0
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'True'
    high: '1'
    high_key: pmt.intern('SET')
    low: '0'
    low_key: pmt.intern('LOW')
  states: {}
- name: satellite_tools_threshold_tag_0_0_0
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'True'
    high: '1'
    high_key: pmt.intern('SET')
    low: '0'
    low_key: pmt.intern('LOW')
  states: {}
- name: satellite_tools_threshold_tag_0_0_0_0
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'True'
    high: '1'
    high_key: pmt.intern('SET')
    low: '0'
    low_key: pmt.intern('LOW')
  states: {}
- name: satellite_tools_threshold_tag_0_1
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'True'
    high: '1'
    high_key: pmt.intern('RESET')
    low: '0'
    low_key: pmt.intern('LOW')
  states: {}
- name: satellite_tools_threshold_tag_0_1_0
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'True'
    high: '1'
    high_key: pmt.intern('RESET')
    low: '0'
    low_key: pmt.intern('LOW')
  states: {}
- name: satellite_tools_threshold_tag_1
  id: satellite_tools_threshold_tag
  parameters:
    en_high: 'True'
    en_low: 'True'
    high: '1'
    high_key: lock_msg
    low: '0'
    low_key: unlock_msg
  states: {}
- name: syncword_cc_hex
  id: parameter
  parameters:
    label: Syncword
    type: str
    value: '''D49C24FF2686'''
  states: {}
- name: unlock_msg
  id: parameter
  parameters:
    hide: part
    label: Unlock Msg
    type: str
    value: UNLOCK
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: I_to_plusQ
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: I_to_minusQ
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Q_to_minusQ
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Detect_180
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Detect_0
  states: {}
- name: virtual_sink_0_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Detect_90
  states: {}
- name: virtual_sink_0_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Detect_Reverse_90
  states: {}
- name: virtual_sink_0_0_1_0_1
  id: virtual_sink
  parameters:
    stream_id: Detect_Reverse_0
  states: {}
- name: virtual_sink_0_0_1_1
  id: virtual_sink
  parameters:
    stream_id: Detect_270
  states: {}
- name: virtual_sink_0_0_1_1_0
  id: virtual_sink
  parameters:
    stream_id: Detect_Reverse_270
  states: {}
- name: virtual_sink_0_0_1_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Latch_Invert_Q
  states: {}
- name: virtual_sink_0_0_1_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Latch_Invert_I
  states: {}
- name: virtual_sink_0_0_1_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Latch_No_Invert_I
  states: {}
- name: virtual_sink_0_0_1_1_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Latch_SwapIQ
  states: {}
- name: virtual_sink_0_0_1_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: Latch_No_Invert_Q
  states: {}
- name: virtual_sink_0_0_1_1_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Latch_No_SwapIQ
  states: {}
- name: virtual_sink_0_0_1_1_0_1
  id: virtual_sink
  parameters:
    stream_id: I_result
  states: {}
- name: virtual_sink_0_0_1_1_0_1_0
  id: virtual_sink
  parameters:
    stream_id: Q_result
  states: {}
- name: virtual_sink_0_0_1_2
  id: virtual_sink
  parameters:
    stream_id: Detect_Reverse_180
  states: {}
- name: virtual_sink_0_0_2
  id: virtual_sink
  parameters:
    stream_id: I
  states: {}
- name: virtual_sink_0_0_2_0
  id: virtual_sink
  parameters:
    stream_id: Q
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: I_to_plusI
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: I_to_minusI
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Q_to_minusI
  states: {}
- name: virtual_sink_0_1_1
  id: virtual_sink
  parameters:
    stream_id: Q_to_plusI
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: Q_to_plusQ
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: I_to_minusI
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Q_to_minusQ
  states: {}
- name: virtual_source_0_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_90
  states: {}
- name: virtual_source_0_0_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_90
  states: {}
- name: virtual_source_0_0_0_0_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_90
  states: {}
- name: virtual_source_0_0_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: Detect_90
  states: {}
- name: virtual_source_0_0_0_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: Detect_90
  states: {}
- name: virtual_source_0_0_0_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_90
  states: {}
- name: virtual_source_0_0_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_180
  states: {}
- name: virtual_source_0_0_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_180
  states: {}
- name: virtual_source_0_0_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_180
  states: {}
- name: virtual_source_0_0_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: Detect_180
  states: {}
- name: virtual_source_0_0_0_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: Detect_180
  states: {}
- name: virtual_source_0_0_0_0_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_180
  states: {}
- name: virtual_source_0_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_0
  states: {}
- name: virtual_source_0_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_0
  states: {}
- name: virtual_source_0_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_0
  states: {}
- name: virtual_source_0_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: Detect_0
  states: {}
- name: virtual_source_0_0_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: Detect_0
  states: {}
- name: virtual_source_0_0_0_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_0
  states: {}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_270
  states: {}
- name: virtual_source_0_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_270
  states: {}
- name: virtual_source_0_0_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_Reverse_270
  states: {}
- name: virtual_source_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: Detect_270
  states: {}
- name: virtual_source_0_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: Detect_270
  states: {}
- name: virtual_source_0_0_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: Detect_270
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: Q_to_plusQ
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: Q_to_plusI
  states: {}
- name: virtual_source_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: Q_to_minusQ
  states: {}
- name: virtual_source_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: Q_to_plusI
  states: {}
- name: virtual_source_0_0_1_2
  id: virtual_source
  parameters:
    stream_id: Latch_No_Invert_I
  states: {}
- name: virtual_source_0_0_1_2_0
  id: virtual_source
  parameters:
    stream_id: Latch_No_Invert_Q
  states: {}
- name: virtual_source_0_0_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: Latch_SwapIQ
  states: {}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: Q_to_minusI
  states: {}
- name: virtual_source_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: Q_to_plusQ
  states: {}
- name: virtual_source_0_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: I
  states: {}
- name: virtual_source_0_0_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: Q_result
  states: {}
- name: virtual_source_0_0_2_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: I_result
  states: {}
- name: virtual_source_0_0_3
  id: virtual_source
  parameters:
    stream_id: Q_to_minusI
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: I_to_plusI
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: I_to_minusQ
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: I_to_plusI
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: I_to_plusQ
  states: {}
- name: virtual_source_0_1_2
  id: virtual_source
  parameters:
    stream_id: Latch_Invert_I
  states: {}
- name: virtual_source_0_1_2_0
  id: virtual_source
  parameters:
    stream_id: Latch_Invert_Q
  states: {}
- name: virtual_source_0_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: Latch_No_SwapIQ
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: I_to_plusQ
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: I_to_minusI
  states: {}
- name: virtual_source_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: Q
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: I_to_minusQ
  states: {}

connections:
- [blocks_and_xx_0_1_0, '0', virtual_sink_0_0_1, '0']
- [blocks_and_xx_0_1_0_1, '0', virtual_sink_0_0_1_0, '0']
- [blocks_and_xx_0_1_0_1_0, '0', virtual_sink_0_0_1_0_0, '0']
- [blocks_and_xx_0_1_0_1_0_0, '0', virtual_sink_0_0_1_0_0_0, '0']
- [blocks_and_xx_0_1_0_1_1, '0', virtual_sink_0_0_1_0_1, '0']
- [blocks_and_xx_0_1_0_2, '0', virtual_sink_0_0_1_1, '0']
- [blocks_and_xx_0_1_0_2_0, '0', virtual_sink_0_0_1_1_0, '0']
- [blocks_and_xx_0_1_0_3, '0', virtual_sink_0_0_1_2, '0']
- [blocks_char_to_float_0_0_1, '0', fir_filter_xxx_1_0_1, '0']
- [blocks_char_to_float_0_0_1, '0', fir_filter_xxx_1_0_1_0_1, '0']
- [blocks_char_to_float_0_0_1_0, '0', fir_filter_xxx_1_0_1_0, '0']
- [blocks_char_to_float_0_0_1_0, '0', fir_filter_xxx_1_0_1_0_1_1, '0']
- [blocks_float_to_char_0, '0', virtual_sink_0, '0']
- [blocks_float_to_char_0_0, '0', virtual_sink_0_1, '0']
- [blocks_float_to_char_0_0_0, '0', virtual_sink_0_0_0, '0']
- [blocks_float_to_char_0_1, '0', virtual_sink_0_0, '0']
- [blocks_float_to_char_0_1_0, '0', virtual_sink_0_1_0, '0']
- [blocks_float_to_char_0_1_0_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_float_to_char_0_2, '0', virtual_sink_0_2, '0']
- [blocks_float_to_char_0_2_0, '0', virtual_sink_0_1_1, '0']
- [blocks_multiply_const_vxx_0_1_0_2_0, '0', blocks_threshold_ff_0_1_0, '0']
- [blocks_multiply_const_vxx_0_1_0_2_0_0, '0', blocks_threshold_ff_0_1, '0']
- [blocks_multiply_const_vxx_0_1_0_2_0_1, '0', blocks_threshold_ff_0_1_1, '0']
- [blocks_multiply_const_vxx_0_1_0_2_0_1_0, '0', blocks_threshold_ff_0_1_0_0, '0']
- [blocks_or_xx_0, '0', virtual_sink_0_0_1_1_0_0, '0']
- [blocks_or_xx_0_0, '0', virtual_sink_0_0_1_1_0_0_1, '0']
- [blocks_or_xx_0_0_0, '0', virtual_sink_0_0_1_1_0_0_0_0, '0']
- [blocks_or_xx_0_0_0_0, '0', blocks_or_xx_0_0_0_0_0, '0']
- [blocks_or_xx_0_0_0_0, '0', virtual_sink_0_0_1_1_0_0_0_0_0, '0']
- [blocks_or_xx_0_0_0_0_0, '0', satellite_tools_threshold_tag_1, '0']
- [blocks_or_xx_0_1, '0', virtual_sink_0_0_1_1_0_0_0, '0']
- [blocks_or_xx_0_1_0, '0', blocks_or_xx_0_0_0_0_0, '1']
- [blocks_or_xx_0_1_0, '0', virtual_sink_0_0_1_1_0_0_1_0, '0']
- [blocks_stream_to_streams_0, '0', digital_map_bb_0_1, '0']
- [blocks_stream_to_streams_0, '0', virtual_sink_0_0_2, '0']
- [blocks_stream_to_streams_0, '1', digital_map_bb_0_1_0, '0']
- [blocks_stream_to_streams_0, '1', virtual_sink_0_0_2_0, '0']
- [blocks_streams_to_stream_0, '0', pad_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_float_to_char_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', blocks_float_to_char_0_2_0, '0']
- [blocks_threshold_ff_0_1, '0', blocks_float_to_char_0_1, '0']
- [blocks_threshold_ff_0_1_0, '0', blocks_float_to_char_0_1_0, '0']
- [blocks_threshold_ff_0_1_0_0, '0', blocks_float_to_char_0_1_0_0, '0']
- [blocks_threshold_ff_0_1_1, '0', blocks_float_to_char_0_0_0, '0']
- [blocks_threshold_ff_0_2, '0', blocks_float_to_char_0_2, '0']
- [digital_map_bb_0, '0', satellite_tools_latch_selector_0, '1']
- [digital_map_bb_0_1, '0', blocks_char_to_float_0_0_1, '0']
- [digital_map_bb_0_1_0, '0', blocks_char_to_float_0_0_1_0, '0']
- [digital_map_bb_0_2, '0', satellite_tools_latch_selector_0_0, '1']
- [fir_filter_xxx_1_0_1, '0', blocks_multiply_const_vxx_0_1_0_2_0, '0']
- [fir_filter_xxx_1_0_1, '0', blocks_threshold_ff_0_0, '0']
- [fir_filter_xxx_1_0_1_0, '0', blocks_multiply_const_vxx_0_1_0_2_0_1_0, '0']
- [fir_filter_xxx_1_0_1_0, '0', blocks_threshold_ff_0_0_0, '0']
- [fir_filter_xxx_1_0_1_0_1, '0', blocks_multiply_const_vxx_0_1_0_2_0_0, '0']
- [fir_filter_xxx_1_0_1_0_1, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_1_0_1_0_1_1, '0', blocks_multiply_const_vxx_0_1_0_2_0_1, '0']
- [fir_filter_xxx_1_0_1_0_1_1, '0', blocks_threshold_ff_0_2, '0']
- [pad_source_0, '0', blocks_stream_to_streams_0, '0']
- [satellite_tools_latch_selector_0, '0', satellite_tools_latch_selector_0_0_0, '0']
- [satellite_tools_latch_selector_0, '0', virtual_sink_0_0_1_1_0_1_0, '0']
- [satellite_tools_latch_selector_0_0, '0', satellite_tools_latch_selector_0_0_0_0, '0']
- [satellite_tools_latch_selector_0_0, '0', virtual_sink_0_0_1_1_0_1, '0']
- [satellite_tools_latch_selector_0_0_0, '0', blocks_streams_to_stream_0, '1']
- [satellite_tools_latch_selector_0_0_0_0, '0', blocks_streams_to_stream_0, '0']
- [satellite_tools_threshold_tag_0, cmd, satellite_tools_latch_selector_0_0_0, ctrl]
- [satellite_tools_threshold_tag_0, cmd, satellite_tools_latch_selector_0_0_0_0, ctrl]
- [satellite_tools_threshold_tag_0_0, cmd, satellite_tools_latch_selector_0_0_0, ctrl]
- [satellite_tools_threshold_tag_0_0, cmd, satellite_tools_latch_selector_0_0_0_0, ctrl]
- [satellite_tools_threshold_tag_0_0_0, cmd, satellite_tools_latch_selector_0_0, ctrl]
- [satellite_tools_threshold_tag_0_0_0_0, cmd, satellite_tools_latch_selector_0, ctrl]
- [satellite_tools_threshold_tag_0_1, cmd, satellite_tools_latch_selector_0_0, ctrl]
- [satellite_tools_threshold_tag_0_1_0, cmd, satellite_tools_latch_selector_0, ctrl]
- [satellite_tools_threshold_tag_1, cmd, pad_sink_0_0, in]
- [virtual_source_0, '0', blocks_and_xx_0_1_0, '0']
- [virtual_source_0_0, '0', blocks_and_xx_0_1_0, '1']
- [virtual_source_0_0_0_0_0_0_0_0, '0', blocks_or_xx_0, '2']
- [virtual_source_0_0_0_0_0_0_0_0_0, '0', blocks_or_xx_0_0_0, '3']
- [virtual_source_0_0_0_0_0_0_0_0_0_0, '0', blocks_or_xx_0_1_0, '2']
- [virtual_source_0_0_0_0_0_0_1, '0', blocks_or_xx_0_0, '1']
- [virtual_source_0_0_0_0_0_0_1_0, '0', blocks_or_xx_0_1, '1']
- [virtual_source_0_0_0_0_0_0_1_0_0, '0', blocks_or_xx_0_0_0_0, '0']
- [virtual_source_0_0_0_0_0_1_0, '0', blocks_or_xx_0, '3']
- [virtual_source_0_0_0_0_0_1_0_0, '0', blocks_or_xx_0_1, '2']
- [virtual_source_0_0_0_0_0_1_0_0_0, '0', blocks_or_xx_0_0_0_0, '3']
- [virtual_source_0_0_0_0_0_2, '0', blocks_or_xx_0, '0']
- [virtual_source_0_0_0_0_0_2_0, '0', blocks_or_xx_0_1, '0']
- [virtual_source_0_0_0_0_0_2_0_0, '0', blocks_or_xx_0_1_0, '1']
- [virtual_source_0_0_0_0_1_0, '0', blocks_or_xx_0_0, '2']
- [virtual_source_0_0_0_0_1_0_0, '0', blocks_or_xx_0_0_0, '2']
- [virtual_source_0_0_0_0_1_0_0_0, '0', blocks_or_xx_0_0_0_0, '2']
- [virtual_source_0_0_0_0_2, '0', blocks_or_xx_0_0, '0']
- [virtual_source_0_0_0_0_2_0, '0', blocks_or_xx_0_0_0, '0']
- [virtual_source_0_0_0_0_2_0_0, '0', blocks_or_xx_0_1_0, '0']
- [virtual_source_0_0_0_1_0, '0', blocks_or_xx_0_0, '3']
- [virtual_source_0_0_0_1_0_0, '0', blocks_or_xx_0_1, '3']
- [virtual_source_0_0_0_1_0_0_0, '0', blocks_or_xx_0_1_0, '3']
- [virtual_source_0_0_0_2, '0', blocks_or_xx_0, '1']
- [virtual_source_0_0_0_2_0, '0', blocks_or_xx_0_0_0, '1']
- [virtual_source_0_0_0_2_0_0, '0', blocks_or_xx_0_0_0_0, '1']
- [virtual_source_0_0_1, '0', blocks_and_xx_0_1_0_1, '1']
- [virtual_source_0_0_1_0, '0', blocks_and_xx_0_1_0_1_0, '1']
- [virtual_source_0_0_1_0_0, '0', blocks_and_xx_0_1_0_1_0_0, '1']
- [virtual_source_0_0_1_1, '0', blocks_and_xx_0_1_0_1_1, '1']
- [virtual_source_0_0_1_2, '0', satellite_tools_threshold_tag_0_1, '0']
- [virtual_source_0_0_1_2_0, '0', satellite_tools_threshold_tag_0_1_0, '0']
- [virtual_source_0_0_1_2_0_0, '0', satellite_tools_threshold_tag_0_0, '0']
- [virtual_source_0_0_2, '0', blocks_and_xx_0_1_0_2, '1']
- [virtual_source_0_0_2_0, '0', blocks_and_xx_0_1_0_2_0, '1']
- [virtual_source_0_0_2_0_0, '0', digital_map_bb_0_2, '0']
- [virtual_source_0_0_2_0_0, '0', satellite_tools_latch_selector_0_0, '0']
- [virtual_source_0_0_2_0_0_0, '0', satellite_tools_latch_selector_0_0_0_0, '1']
- [virtual_source_0_0_2_0_0_0_0, '0', satellite_tools_latch_selector_0_0_0, '1']
- [virtual_source_0_0_3, '0', blocks_and_xx_0_1_0_3, '1']
- [virtual_source_0_1, '0', blocks_and_xx_0_1_0_1, '0']
- [virtual_source_0_1_0, '0', blocks_and_xx_0_1_0_1_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_and_xx_0_1_0_1_0_0, '0']
- [virtual_source_0_1_1, '0', blocks_and_xx_0_1_0_1_1, '0']
- [virtual_source_0_1_2, '0', satellite_tools_threshold_tag_0_0_0, '0']
- [virtual_source_0_1_2_0, '0', satellite_tools_threshold_tag_0_0_0_0, '0']
- [virtual_source_0_1_2_0_0, '0', satellite_tools_threshold_tag_0, '0']
- [virtual_source_0_2, '0', blocks_and_xx_0_1_0_2, '0']
- [virtual_source_0_2_0, '0', blocks_and_xx_0_1_0_2_0, '0']
- [virtual_source_0_2_0_0, '0', digital_map_bb_0, '0']
- [virtual_source_0_2_0_0, '0', satellite_tools_latch_selector_0, '0']
- [virtual_source_0_3, '0', blocks_and_xx_0_1_0_3, '0']

metadata:
  file_format: 1
